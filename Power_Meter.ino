#define TINY_GSM_MODEM_SIM900

#include "Header.h"
#include "ModbusMaster.h"
#include <SoftwareSerial.h>
#include <LiquidCrystal_I2C.h>
#include <TinyGsmClient.h>
#include <PubSubClient.h>
#include <SD.h>

ModbusMaster node1;
ModbusMaster node2;
ModbusMaster node3;

LiquidCrystal_I2C lcd(0x27, 20, 4);
TinyGsm modem(Serial1);
TinyGsmClient GsmClient(modem);
PubSubClient client;
File myFile;

void modbusRTU() {
  int buffersize = 56;
  uint16_t data11[buffersize], data12[buffersize];
  uint16_t data21[buffersize], data22[buffersize];
  uint16_t data31[buffersize], data32[buffersize];
  uint8_t i;
  uint8_t j;
  uint8_t result, result1;
  
//  Serial.println();
  //-------------Read Node 1--------------------
  //0x03(ReadHoldingRegister) read data address
  result = node1.readHoldingRegisters(2999, 56);

  if (result == node1.ku8MBSuccess) {
    for (j = 0; j < buffersize; j++) {
      data11[j] = node1.getResponseBuffer(j);
//      Serial.print(j); Serial.print("->"); Serial.println(data11[j]);
    }
//    Serial.println();
//      parameter Low and High address (EX: address 1, maka decode (0, 1))
    cAC1 = int2float(data11[0], data11[1]);
    vAC1 = int2float(data11[28], data11[29]);
    acPow1 = int2float(data11[54], data11[55]);
  }
  else{
    cAC1 = 0.00;
    vAC1 = 0.00;
    acPow1 = 0.00;
  }
  
  result1 = node1.readHoldingRegisters(3056, 56);
  if (result1 == node1.ku8MBSuccess)
  {
    for (i = 0; i < buffersize; i++) {
      data12[i] = node1.getResponseBuffer(i);
//      Serial.print(i); Serial.print("->>"); Serial.println(data12[i]);
    }
    rp1 = int2float(data12[11], data12[12]);
    app1 = int2float(data12[19], data12[20]);
    pf1 = int2float(data12[27], data12[28]);
    freq1 = int2float(data12[53], data12[54]);
  }
  else {
    rp1 = 0.00;
    app1 = 0.00;
    pf1 = 0.00;
    freq1 = 0.00;
  }
  
  delay(300);
//  Serial.println();
  //-------------Read Node 2--------------------
  result = node2.readHoldingRegisters(2999, 56);

  if (result == node2.ku8MBSuccess) {
    for (j = 0; j < buffersize; j++) {
      data21[j] = node2.getResponseBuffer(j);
//      Serial.print(j); Serial.print("->"); Serial.println(data1[j]);
    }
//    Serial.println();
    //parameter Low and High address (EX: address 1, maka decode (0, 1))
    cAC2 = int2float(data21[0], data21[1]);
    vAC2 = int2float(data21[28], data21[29]);
    acPow2 = int2float(data21[54], data21[55]);
  }
  else{
    cAC2 = 0.00;
    vAC2 = 0.00;
    acPow2 = 0.00;
  }

  result1 = node2.readHoldingRegisters(3056, 56);
  if (result1 == node2.ku8MBSuccess)
  {
    for (i = 0; i < buffersize; i++) {
      data22[i] = node2.getResponseBuffer(i);
//      Serial.print(i); Serial.print("->>"); Serial.println(data22[i]);
    }
    rp2 = int2float(data22[11], data22[12]);
    app2 = int2float(data22[19], data22[20]);
    pf2 = int2float(data22[27], data22[28]);
    freq2 = int2float(data22[53], data22[54]);
  }
  else {
    rp2 = 0.00;
    app2 = 0.00;
    pf2 = 0.00;
    freq2 = 0.00;
  }
  
  delay(300);
  //-------------Read Node 3--------------------
  result = node3.readHoldingRegisters(2999, 56);
  if (result == node3.ku8MBSuccess) {
    for (j = 0; j < buffersize; j++) {
      data31[j] = node3.getResponseBuffer(j);
//      Serial.print(j); Serial.print("->"); Serial.println(data311[j]);
    }
    //parameter Low and High address (EX: address 1, maka decode (0, 1))
    cAC3 = int2float(data31[0], data31[1]);
    vAC3 = int2float(data31[28], data31[29]);
    acPow3 = int2float(data31[54], data31[55]);
  }
  else{
    cAC3 = 0.00;
    vAC3 = 0.00;
    acPow3 = 0.00;
  }
  
  result1 = node3.readHoldingRegisters(3056, 56);
  if (result1 == node3.ku8MBSuccess)
  {
    for (i = 0; i < buffersize; i++) {
      data32[i] = node3.getResponseBuffer(i);
//      Serial.print(i); Serial.print("->>"); Serial.println(data32[i]);
    }
    rp3 = int2float(data32[11], data32[12]);
    app3 = int2float(data32[19], data32[20]);
    pf3 = int2float(data32[27], data32[28]);
    freq3 = int2float(data32[53], data32[54]);
  }
  else {
    rp3 = 0.00;
    app3 = 0.00;
    pf3 = 0.00;
    freq3 = 0.00;
  }
}

float int2float(uint16_t d1, uint16_t d2) { //decode data address Modbuss
  int16_t value[2] = {d2, d1};
  float f;

  memcpy(reinterpret_cast<void*>(&f), reinterpret_cast<void const*>(value), sizeof f);
  return f;
}

void firstMenu() {
  lcd.setCursor(0, 0); lcd.print("====================");
  lcd.setCursor(0, 1); lcd.print("| SMART MONITORING |");
  lcd.setCursor(0, 2); lcd.print("|      PT PJB      |");
  lcd.setCursor(0, 3); lcd.print("====================");
}

void menuInfo() {
  lcd.clear();
  lcd.setCursor(0, 0); lcd.print("  SMART MONITORING  ");
  lcd.setCursor(0, 1); lcd.print("    PLTHK PAITON    ");
  lcd.setCursor(0, 2); lcd.print("       PT PJB       ");
  lcd.setCursor(0, 3); lcd.print("    UPPTN - BBTK    ");
}

void menuAc11() {
  lcd.clear();
  lcd.setCursor(0, 0); lcd.print("Teg  1 : "); lcd.print(vACBuff1);
  lcd.setCursor(0, 1); lcd.print("Arus 1 : "); lcd.print(cACBuff1);
  lcd.setCursor(0, 2); lcd.print("PF   1 : "); lcd.print(pfBuff1);
  lcd.setCursor(0, 3); lcd.print("Freq 1 : ");  lcd.print(freqBuff1);
}

void menuAc12() {
  lcd.clear();
  lcd.setCursor(0, 0); lcd.print("P Akt 1 : "); lcd.print(acPBuff1);
  lcd.setCursor(0, 1); lcd.print("P Rea 1 : "); lcd.print(rPBuff1);
  lcd.setCursor(0, 2); lcd.print("P App 1 : "); lcd.print(apPBuff1);
  lcd.setCursor(0, 3); lcd.print("P(I*V)1 : "); lcd.print(dACBuff1);
}

void menuAc21() {
  lcd.clear();
  lcd.setCursor(0, 0); lcd.print("Teg  2 : "); lcd.print(vACBuff2);
  lcd.setCursor(0, 1); lcd.print("Arus 2 : "); lcd.print(cACBuff2);
  lcd.setCursor(0, 2); lcd.print("PF   2 : "); lcd.print(pfBuff2);
  lcd.setCursor(0, 3); lcd.print("Freq 2 : ");  lcd.print(freqBuff2);
}

void menuAc22() {
  lcd.clear();
  lcd.setCursor(0, 0); lcd.print("P Akt 2 : "); lcd.print(acPBuff2);
  lcd.setCursor(0, 1); lcd.print("P Rea 2 : "); lcd.print(rPBuff2);
  lcd.setCursor(0, 2); lcd.print("P APP 2 : "); lcd.print(apPBuff2);
  lcd.setCursor(0, 3); lcd.print("P(I*V)2 : "); lcd.print(dACBuff2);
}

void menuAc31() {
  lcd.clear();
  lcd.setCursor(0, 0); lcd.print("Teg  3 : "); lcd.print(vACBuff3);
  lcd.setCursor(0, 1); lcd.print("Arus 3 : "); lcd.print(cACBuff3);
  lcd.setCursor(0, 2); lcd.print("PF   3 : "); lcd.print(pfBuff3);
  lcd.setCursor(0, 3); lcd.print("Freq 3 : ");  lcd.print(freqBuff3);
}

void menuAc32() {
  lcd.clear();
  lcd.setCursor(0, 0); lcd.print("P Akt 3 : "); lcd.print(acPBuff3);
  lcd.setCursor(0, 1); lcd.print("P Rea 3 : "); lcd.print(rPBuff3);
  lcd.setCursor(0, 2); lcd.print("P APP 3 : "); lcd.print(apPBuff3);
  lcd.setCursor(0, 3); lcd.print("P(I*V)3 : "); lcd.print(dACBuff3);
}

void LCD(){
    if (MenuChoice == 0) {
      menuInfo();
    }
    else if (MenuChoice == 1) {
      menuAc11();
    }
    else if (MenuChoice == 2) {
      menuAc12();
    }
    else if (MenuChoice == 3) {
      menuAc21();
    }
    else if (MenuChoice == 4) {
      menuAc22();
    }
    else if (MenuChoice == 5) {
      menuAc31();
    }
    else if (MenuChoice == 6) {
      menuAc32();
    }

    if (MenuChoice == 6) {
      MenuChoice = 0;
    }
    else {
      MenuChoice = MenuChoice + 1;
    }
}

void showData() {
  modbusRTU();

  char pr1[5], pr2[5], pr3[5];

  if(rp1 < 0)
    sprintf(pr1, "-%d", abs((int)(rp1 * 1000)));
  else
    sprintf(pr1, "%d", (int)(rp1 * 1000));

  if(rp2 < 0)
    sprintf(pr2, "-%d", abs((int)(rp2 * 1000)));
  else
    sprintf(pr2, "%d", (int)(rp2 * 1000));

  if(rp3 < 0)
    sprintf(pr3, "-%d", abs((int)(rp2 * 1000)));
  else
    sprintf(pr3, "%d", (int)(rp2 * 1000));
  

  //data to char array TO lcd
  sprintf(vACBuff1, "%d.%02d V", (int)vAC1, (int)(vAC1*100)%100);
  sprintf(cACBuff1, "%d.%02d A", (int)cAC1, (int)(cAC1*100)%100);
  sprintf(rPBuff1, "%s.%02d kVAR", pr1, abs((int)((rp1 * 1000)*100)%100));
  sprintf(dACBuff1, "%d.%02d W", (int)(vAC1 * cAC1), (int)((vAC1 * cAC1)*100)%100);
  sprintf(acPBuff1, "%d.%02d W", (int)(acPow1 * 1000), abs((int)((acPow1 * 1000)*100)%100));
  sprintf(pfBuff1, "%d.%02d", (int)pf1, abs((int)(pf1*100)%100));
  sprintf(apPBuff1, "%d.%02d kVA", (int)(app1 * 1000), (int)((app1 * 1000)*100)%100);
  sprintf(freqBuff1, "%d.%02d Hz", (int)freq1, (int)(freq1*100)%100);

  sprintf(vACBuff2, "%d.%02d V", (int)vAC2, (int)(vAC2*100)%100);
  sprintf(cACBuff2, "%d.%02d A", (int)cAC2, (int)(cAC2*100)%100);
  sprintf(rPBuff2, "%s.%02d kVAR", pr2, abs((int)((rp2 * 1000)*100)%100));
  sprintf(dACBuff2, "%d.%02d W", (int)(vAC2 * cAC2), (int)((vAC2 * cAC2)*100)%100);
  sprintf(acPBuff2, "%d.%02d W", (int)(acPow2 * 1000), abs((int)((acPow2 * 1000)*100)%100));
  sprintf(pfBuff2, "%d.%02d", (int)pf2, abs((int)(pf2*100)%100));
  sprintf(apPBuff2, "%d.%02d kVA", (int)(app2 * 1000), (int)((app2 * 1000)*100)%100);
  sprintf(freqBuff2, "%d.%02d Hz", (int)freq2, (int)(freq2*100)%100);

  sprintf(vACBuff3, "%d.%02d V", (int)vAC3, (int)(vAC3*100)%100);
  sprintf(cACBuff3, "%d.%02d A", (int)cAC3, (int)(cAC3*100)%100);
  sprintf(rPBuff3, "%s.%02d kVAR", pr3, abs((int)((rp3 * 1000)*100)%100));
  sprintf(dACBuff3, "%d.%02d W", (int)(vAC3 * cAC3), (int)((vAC3 * cAC3)*100)%100);
  sprintf(acPBuff3, "%d.%02d W", (int)(acPow3 * 1000), abs((int)((acPow3 * 1000)*100)%100));
  sprintf(pfBuff3, "%d.%02d", (int)pf3, abs((int)(pf3*100)%100));
  sprintf(apPBuff3, "%d.%02d kVA", (int)(app3 * 1000), (int)((app3 * 1000)*100)%100);
  sprintf(freqBuff3, "%d.%02d Hz", (int)freq3, (int)(freq3*100)%100);

    //data to char array TO lcd
//  sprintf(databuff11, "PTN-PLTHK1-DATA1; VOLT : %s; CURRENT : %s; PFAK : %s; FREQ : %s;", vACBuff1, cACBuff1, pfBuff1, freqBuff1);
//  sprintf(databuff12, "PTN-PLTHK1-DATA2; PAK : %s; PREA : %s; PAPP : %s; P(I*V) : %s;", acPBuff1, rPBuff1, apPBuff1, dACBuff1);
//  sprintf(databuff21, "PTN-PLTHK2-DATA1; VOLT : %s; CURRENT : %s; PFAK : %s; FREQ : %s;", vACBuff2, cACBuff2, pfBuff2, freqBuff2);
//  sprintf(databuff22, "PTN-PLTHK2-DATA2; PAK : %s; PREA : %s; PAPP : %s; P(I*V) : %s;", acPBuff2, rPBuff2, apPBuff2, dACBuff2);
//  sprintf(databuff31, "PTN-PLTHK3-DATA1; VOLT : %s; CURRENT : %s; PFAK : %s; FREQ : %s;", vACBuff3, cACBuff3, pfBuff3, freqBuff3);
//  sprintf(databuff32, "PTN-PLTHK3-DATA2; PAKT : %s; PREAK : %s; PAPP : %s; P(I*V) : %s;", acPBuff3, rPBuff3, apPBuff3, dACBuff3);

  sprintf(databuff1, "PTN-PLTHK-VOLTAGE; V1 : %s; V2 : %s; V3 : %s;", vACBuff1, vACBuff2, vACBuff3);
  sprintf(databuff2, "PTN-PLTHK-CURRENT; I1 : %s; I2 : %s; I3 : %s;", cACBuff1, cACBuff2, cACBuff3);
  sprintf(databuff3, "PTN-PLTHK-POWRFTR; PF1 : %s; PF2 : %s; PF3 : %s;", pfBuff1, pfBuff2, pfBuff3);
  sprintf(databuff4, "PTN-PLTHK-FREQNCY; F1 : %s; F2 : %s; F3 : %s;", freqBuff1, freqBuff2, freqBuff3);
  sprintf(databuff5, "PTN-PLTHK-ACTPOWR; AP1 : %s; AP2 : %s; AP3 : %s;", acPBuff1, acPBuff2, acPBuff3);
  sprintf(databuff6, "PTN-PLTHK-REAPOWR; RP1 : %s; RP2 : %s; RP3 : %s;", rPBuff1, rPBuff2, rPBuff3);
  sprintf(databuff7, "PTN-PLTHK-APPPOWR; ApP1 : %s; ApP2 : %s; ApP3 : %s;", apPBuff1, apPBuff2, apPBuff3);
  sprintf(databuff8, "PTN-PLTHK-POWRCAL; PC1 : %s; PC2 : %s; PC3 : %s;", dACBuff1, dACBuff2, dACBuff3);
}

void reconnect() {
  while (!client.connected()) {
    lcd.clear();
    lcd.setCursor(0, 0); lcd.print("MQTT Connection...");
    if (client.connect("Mega2560Client", mqtt_user, mqtt_password)) {
      lcd.setCursor(0, 1); lcd.print("Connected");
      kirim = 0;
    } else {
      lcd.setCursor(0, 2); lcd.print("Failed, rc = "); lcd.print(client.state());
      currentMillis = millis();
      if (currentMillis - previousMillisSD >= IntervalSend) {
        previousMillisSD = currentMillis;
        sendSD2();
        lcd.setCursor(0, 3); lcd.print("Send to SD Card");
        delay(1000);
        kirim = 1;
        ConnectGSM2();
      }
      // Wait 5 seconds before retrying
      delay(4000);
    }
  }
}

void sendData() {
  showData();
  if (!client.connected()) {
    reconnect();
  }
  client.loop();

  client.publish(Tag1, databuff1);
  client.publish(Tag2, databuff2);
  client.publish(Tag3, databuff3);
  client.publish(Tag4, databuff4);
  client.publish(Tag5, databuff5);
  client.publish(Tag6, databuff6);
  client.publish(Tag7, databuff7);
  client.publish(Tag8, databuff8);
}

void sendSD(){
  showData();
  myFile = SD.open(filename, FILE_WRITE);

  if(myFile){
    countA++;
    myFile.println();
    myFile.println("===============================================");
    myFile.print("NO DATA : ");
    myFile.print(countA);
    myFile.println("  || MQTT STATUS -> CONNECTED -> SEND TO MQTT ||");
    myFile.println("===============================================");
    myFile.println(databuff1);
    myFile.println(databuff2);
    myFile.println(databuff3);
    myFile.println(databuff4);
    myFile.println(databuff5);
    myFile.println(databuff6);
    myFile.println(databuff7);
    myFile.println(databuff8);
    myFile.println("===============================================");
    
    myFile.close();
  }
}

void sendSD2(){
  showData();
  myFile = SD.open(filename, FILE_WRITE);
  
  if(myFile){
    countB++;
    myFile.println();
    myFile.println("===============================================");
    myFile.print("NO DATA : ");
    myFile.print(countB);
    myFile.println("  || MQTT STATUS -> DISCONNECTED -> NOT SEND ||");
    myFile.println("===============================================");
    myFile.println(databuff1);
    myFile.println(databuff2);
    myFile.println(databuff3);
    myFile.println(databuff4);
    myFile.println(databuff5);
    myFile.println(databuff6);
    myFile.println(databuff7);
    myFile.println(databuff8);
    myFile.println("===============================================");

    myFile.close();
  }
}

void SDCard(){
  lcd.clear();
  lcd.setCursor(0, 0); lcd.print("Initializing SD card...");
  if (!SD.begin(pinSDCard)) {
    lcd.setCursor(0, 1); lcd.print("Initializing Failed!");
    while (1);
  }

  lcd.setCursor(0, 2); lcd.print("Initializing Done.");
  if (SD.exists(filename)) {
    lcd.setCursor(0, 3); lcd.print(filename + " Available");
  } else {
    lcd.setCursor(0, 3); lcd.print("Creating " + filename);
  }
  myFile = SD.open(filename, FILE_WRITE);
  if(myFile){
    myFile.println();
    myFile.println("===============================================");
    myFile.println("===============================================");
    myFile.println("|               SMART MONITORING               |");
    myFile.println("|                    PT PJB                    |");
    myFile.println("===============================================");
    myFile.println("|                 SYSTEM START                 |");
    myFile.println("===============================================");
    myFile.println("===============================================");
    myFile.close();
  }
  
  delay(2000);
}

void ConnectGSM(){
  lcd.clear();
  lcd.setCursor(0, 0); lcd.print("System Start");
  modem.restart();
  lcd.setCursor(0, 1); lcd.print(modem.getModemInfo());
  if(!modem.waitForNetwork())
  {
    lcd.setCursor(0, 1); lcd.print("Failed...");
    while(true);
  }
  lcd.setCursor(0, 2); lcd.print("Telkomsel");
  if (!modem.gprsConnect(apn, user, pass))
  {
    lcd.setCursor(0, 3); lcd.print("Failed...");
    while(true);
  }
  lcd.setCursor(0, 3); lcd.print(String(apn));
  delay(2000);
}

void ConnectGSM2(){
  lcd.clear();
  lcd.setCursor(0, 0); lcd.print("System Start");
  modem.restart();
  lcd.setCursor(0, 1); lcd.print(modem.getModemInfo());
  if(!modem.waitForNetwork())
  {
    lcd.setCursor(0, 1); lcd.print("Failed...");
    if(kirim){
      sendSD2();
      lcd.setCursor(0, 3); lcd.print("Send to SD Card");
      delay(1000);
      reconnect();
    }
  }
  lcd.setCursor(0, 2); lcd.print("Telkomsel");
  if (!modem.gprsConnect(apn, user, pass))
  {
    lcd.setCursor(0, 2); lcd.print("Failed...");
    if(kirim){
        sendSD2();
        lcd.setCursor(0, 3); lcd.print("Send to SD Card");
        delay(1000);
        reconnect();
    }
  }
  else
    lcd.setCursor(0, 3); lcd.print(String(apn));
  
  delay(2000);
}

void setup(){
  Serial.begin(19200);
  Serial1.begin(9600);
  pinMode(pinSDCard, OUTPUT);
  
  node1.begin(slaveID1, Serial);
  node2.begin(slaveID2, Serial);
  node3.begin(slaveID3, Serial);

  lcd.init();
  lcd.backlight();
  firstMenu();
  delay(5000);
  ConnectGSM();
  SDCard();

  client.setClient(GsmClient);
  client.setServer(mqtt_server, mqtt_port);
}

void loop() {
  currentMillis = millis();
  if (currentMillis - previousMillisSend >= IntervalSend) {
    previousMillisSend = currentMillis;
    sendSD();
  }

  currentMillis = millis();
  if (currentMillis - previousMillisMqtt >= IntervalMqtt) {
    previousMillisMqtt = currentMillis;
    sendData();
  }

  currentMillis = millis();
  if (currentMillis - previousMillisLCD >= IntervalLCD) {
    showData();
    previousMillisLCD = currentMillis;
    LCD();
  }
}
